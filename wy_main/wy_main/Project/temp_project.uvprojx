# Keil uVision project temp_project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temp_project +hex
  AfterMake: fromelf --bin --output bin\project.bin Objects\temp_project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\LED_Drive;..\User\KEY_Drive;..\User\EXTI_Drive;..\User\BUZ_Drive;..\User\Systick_Dirve;..\User\TIM_Dirve;..\User\USART_Dirve;..\User\DMA_Drive;..\User\HC_05_Drive;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\SYSTEM\sys;..\SYSTEM\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STSRTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c OSP_fifo.c
    ../User/LED_Drive/: LED.c
    ../User/KEY_Drive/: key_drive.c
    ../User/EXTI_Drive/: EXTI_Dirve.c
    ../User/BUZ_Drive/: BUZ_Dirve.c
    ../User/Systick_Dirve/: Systick_Dirve.c
    ../User/TIM_Dirve/: TIM_Dirve.c
    ../User/USART_Dirve/: USART_Dirve.c
    ../User/DMA_Drive/: DMA_Drive.c
    ../User/HC_05_Drive/: hc_05_drive.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.h delay.c
